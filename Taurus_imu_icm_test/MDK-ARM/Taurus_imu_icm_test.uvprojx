# Keil uVision project Taurus_imu_icm_test.uvprojx, settings and files
target Taurus_imu_icm_test (6220000::V6.22::ARMCLANG)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801BFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Taurus_imu_icm_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,ARM_MATH_CM4,__FPU_PRESENT=1U,__FPU_USED=1U
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Compoents;../mathlib;../dsp;../dsp/Include;../Bsp;../mathlib/Algorithm;../Communication
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fdcan.c iwdg.c spi.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_fdcan.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Components
    ../Compoents/: ICM42688_driver.c ICM42688_reg.h ICM42688_Middleware.c ICM42688_Middleware.h
  group Bsp
    ../Bsp/: bsp_dwt.c bsp_dwt.h bsp_imu.c bsp_imu.h bsp_PWM.c bsp_PWM.h bsp_flash.c bsp_flash.h
  group Mathlib
    ../mathlib/: Calibration.c Calibration.h data_processing.c data_processing.h kalman_filter.c kalman_filter.h mytype.h pid.c pid.h Mahony.c ekf_attitude.c
    ../mathlib/Algorithm/: QuaternionEKF.c QuaternionEKF.h
  group Dsp
    ../dsp/: arm_cortexM4lf_math.lib
  group Communication
    ../Communication/: can_comm.c can_comm.h
software components: CMSIS:CORE 6.1.0
